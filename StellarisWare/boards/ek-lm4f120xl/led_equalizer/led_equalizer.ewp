# IAR project led_equalizer.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM4F120H5QR TexasInstruments LM4F120H5QR
  ICCARM.CCDefines: ewarm; PART_LM4F120H5QR; TARGET_IS_BLIZZARD_RA1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..; ..\..\..\dsplib
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: led_equalizer.bin
  ILINK.IlinkOutputFile: led_equalizer.out
  ILINK.IlinkIcfFile: led_equalizer.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm4f/Exe/: driverlib-cm4f.a
  group Source
    ./: led_equalizer.c startup_ewarm.c ti_hamming_window_vector.c ti_sample_sine_vector2.c
    ../../../utils/: uartstdio.c
